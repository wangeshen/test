# IAR project COM.MXCHIP.CLOUD.ewp, settings and files
configuration EMW3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\EMW3162; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash; ..\..\..\Library\MicoCloudService; ..\..\..\Library\MicoCloudService\MicoMQTTClient; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTClient-C\src\MICO; ..\..\..\Library\MicoCloudService\MicoMQTTClient\MQTTPacket\src
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.MXCHIP.CLOUD.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.CLOUD.out
  ILINK.IlinkIcfFile: ..\..\..\Platform\EMW3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICO_EVB_1 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\MICO_EVB_1; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M3; ..\..\..\Platform\Common\Cortex-M3\STM32F2xx\STM32F2xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\MICO_EVB_1\micoLinkerForIAR.icf
configuration Nucleo_411RE (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.MXCHIP.CLOUD; ..\..\..\MICO; ..\..\..\Platform\Nucleo_411RE; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\include; ..\..\..\External; ..\..\..\Platform\include; ..\..\..\Platform\Common\Cortex-M4; ..\..\..\Platform\Common\Cortex-M4\STM32F4xx\STM32F4xx_Drv; ..\..\..\Platform\Common\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\Platform\Nucleo_411RE\micoLinkerForIAR.icf
  group Application
    ../../../Demos/COM.MXCHIP.CLOUD/: HaProtocol.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h UartRecv.c
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group include
    ../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a mxchipWNet_cm4f_spi.a
  group Library/MicoCloudService
    ../../../Library/MicoCloudService/: MicoCloudService.c MicoCloudService.h MicoCloudServiceDef.h MicoCloudServiceVersion.c
  group Library/MicoCloudService/MicoMQTTClient
    ../../../Library/MicoCloudService/MicoMQTTClient/: MicoMQTTClient.c MicoMQTTClient.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/: MQTTClient.c MQTTClient.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/MICO
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTClient-C/src/MICO/: MQTTMICO.c MQTTMICO.h
  group Library/MicoCloudService/MicoMQTTClient/MQTTPacket/src
    ../../../Library/MicoCloudService/MicoMQTTClient/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group MICO
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
  group MICO/WAC
    ../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../MICO/WPS/: WPS.c
  group Platform/common/Cortex-M3
    ../../../Platform/Common/Cortex-M3/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M3/STM32F2xx
    ../../../Platform/Common/Cortex-M3/STM32F2xx/: gpio_irq.c gpio_irq.h MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f2xx_platform.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SDIO/: wlan_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M3/STM32F2xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/: startup_stm32f2xx_IAR.s stm32f2xx.h stm32f2xx_conf.h system_stm32f2xx.c
  group Platform/common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M3/STM32F2xx/STM32F2xx_Drv/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/common/Cortex-M4
    ../../../Platform/Common/Cortex-M4/: crt0_IAR.c hardfault.c
  group Platform/common/Cortex-M4/STM32F4xx
    ../../../Platform/Common/Cortex-M4/STM32F4xx/: gpio_irq.c MicoDriverAdc.c MicoDriverFlash.c MicoDriverGpio.c MicoDriverI2c.c MicoDriverPwm.c MicoDriverRng.c MicoDriverRtc.c MicoDriverSpi.c MicoDriverUart.c MicoDriverWdg.c rtc.c stm32f4xx_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/: read_wifi_firmware.c wlan_platform.c
  group Platform/common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI
    ../../../Platform/Common/Cortex-M4/STM32F4xx/EMW1062_Driver/SPI/: wwd_bus.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/: startup_stm32f411xe_IAR.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c
  group Platform/common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver
    ../../../Platform/Common/Cortex-M4/STM32F4xx/STM32F4xx_Drv/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/common/Drivers/spi_flash
    ../../../Platform/Common/Drivers/spi_flash/: MICO_EVB_1.c spi_flash.c
  group Platform/common/IAR
    ../../../Platform/Common/IAR/: stdio_IAR.c
  group Platform/EMW3162
    ../../../Platform/EMW3162/: platform.c platform.h platform_common_config.h
  group Platform/MICO_EVB_1
    ../../../Platform/MICO_EVB_1/: platform.c platform.h platform_common_config.h
  group Platform/Nucleo_411RE
    ../../../Platform/Nucleo_411RE/: platform.c platform.h platform_common_config.h
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
